# Keil uVision project FreeRTOS.uvprojx, settings and files
target TM4C123 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c mytasks.c
  group driver/pll
    ./driver/: pll.c
  group driver/lcd_i2c
    ./driver/lcd_i2c/: i2c1.c lcd1602_i2c.c
  group driver/rdm6300
    ./driver/rdm6300/: RDM6300.c uart0.c uart1.c
  group driver/sdcard
    ./driver/sdcard/: diskio.c ff.c ssi0.c ffsystem.c
  group driver/sdcard/rtc
    ./driver/sdcard/rtc/: DS1307.c
software components: RTOS:Config 9.0.0, RTOS:Core 9.0.0, RTOS:Event Groups 9.0.0, RTOS:Heap 9.0.0, RTOS:Timers 9.0.0, CMSIS:CORE 5.0.1, CMSIS:RTOS2:FreeRTOS 9.0.0, Device:Startup 1.0.1
